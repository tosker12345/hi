# Keil uVision project i2c_test.uvprojx, settings and files
target i2c_test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c_test
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_tim.c stm32f3xx_hal_flash.c stm32f3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
